
require recipes-openxt/tboot/tboot.inc

SRC_URI[md5sum] = "1913ec6170a10f16fdcc2220b6f45d4a"
SRC_URI[sha256sum] = "01e8329c59ef0d8e06e12c1bbee007348272269ff11765aedafc5961f79567b6"
